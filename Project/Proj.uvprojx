# Keil uVision project Proj.uvprojx, settings and files
target STM32f103_RGB_Project (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Proj +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Lib\startup\arm;..\Lib\cmsis;..\Lib\src;..\Lib\inc;..\USER;..\USER\Library\inc;..\USER\Library\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Lib/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Lib/cmsis/: core_cm3.c system_stm32f10x.c stm32f10x.h
  group FWLB
    ../Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../USER/: stm32f10x_conf.h stm32f10x_it.c main.c stm32f10x_rgb_appliction.c
    ../USER/Library/inc/: matrix_config.h
  group MATRIX_Lib
    ../USER/Library/src/: stm32f10x_rgb_init.c stm32f10x_rgb_uart.c stm32f10x_rgb_rtc.c stm32f10x_rgb_i2c.c stm32f10x_rgb_err.c stm32f10x_rgb_spi_flash.c stm32f10x_rgb_systick.c stm32f10x_rgb_matrix.c stm32f10x_rgb_dht11.c stm32f10x_rgb_gfx.c stm32f10x_rgb_Fonts.c stm32f10x_rgb_adc.c stm32f10x_rgb_ColorHSV.c
  group Document
    ../Doc/: README.txt
